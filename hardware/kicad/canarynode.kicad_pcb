# Repository aboller1212/canarynode

File README.md:

# CANaryNode

A CAN FD sensor node built around an STM32G474. It reads an IMU and an
environmental sensor and puts the data on a CAN bus. The firmware is
bare-metal — no HAL, no RTOS, no generated code, just CMSIS headers and the
reference manual. I'm building it this way because I want to understand what
every peripheral is actually doing at the register level, not call somebody's
library function and hope.

I designed the board as well, so the schematic and layout live in this repo
alongside the firmware.

## Hardware

The custom board is a 4-layer PCB with:

- STM32G474RCT6 (Cortex-M4F, 256K flash)
- BMI270 IMU on SPI
- BME280 temperature/pressure/humidity sensor on I2C (SDO tied to ground, so
  address 0x76)
- TI TCAN CAN FD transceiver
- USB-C
- Four LEDs, a button, and headers for SWD and UART

Most of the driver work was done on a Nucleo-G474RE first, bringing up one
peripheral at a time, so that porting to the real board would mostly be
remapping pins. The custom board is here now and boots.

A couple of things differ between the two: the Nucleo has a G474RET6 (512K
flash) and routes CAN to FDCAN1 on PA11/PA12, while my board uses an RCT6
(256K) and puts CAN on PB5/PB6, which is FDCAN2. That's an instance swap, not
just a pin change, so it needs its own message RAM offset. My board uses
PA11/PA12 for USB instead.

Pin map on the custom board:

| Function | Pins |
| --- | --- |
| LEDs | PB0, PB1, PB2, PC4 |
| I2C1 (BME280) | PA15 SCL, PB7 SDA |
| SPI1 (BMI270) | PA4 CS, PA5 SCK, PA6 MISO, PA7 MOSI |
| FDCAN2 | PB5 RX, PB6 TX |
| USB | PA11, PA12 |
| SWD | PA13, PA14, NRST on PG10 |
| USART2 | PA2, PA3 |
| BOOT0 jumper | PB8 |
| IMU interrupt | PB10 |

## Layout

- `firmware/` — the STM32 firmware, where most of the work is
- `hardware/` — schematic and board files
- `docs/` — datasheets and my bring-up notes
- `tools/` — scripts

## Building

CMake + Ninja with the arm-none-eabi GCC toolchain.

    cd firmware
    cmake -B build -G Ninja
    cmake --build build

Produces `build/canary_firmware` (ELF) and a `.bin` next to it.

## Flashing

Two ways, depending on the board.

The custom board can be programmed over USB with no debugger at all. The
STM32 has a bootloader burned into ROM — jumper BOOT0 high, plug in USB-C,
and it enumerates as a DFU device:

    STM32_Programmer_CLI -c port=USB1 -w build/canary_firmware.bin 0x08000000

Pull the jumper and power cycle to run the firmware instead. That's handy for
quick iteration, but DFU only programs — for actual debugging I use OpenOCD as
a GDB server with arm-none-eabi-gdb over SWD.

On the Nucleo I use an external ST-Link V2 on SWD (SWDIO to PA13, SWCLK to
PA14, plus GND and 3V3). The onboard ST-Link V3E doesn't work reliably from an
Apple Silicon Mac, so its USB stays unplugged and the target gets power from
the V2.

## Status

Working and verified on the custom board:

- It powers up, enumerates over USB, and takes a verified flash write.
- LED blink driven by a TIM6 timer interrupt. Small thing on its own, but it's
  the first proof that my startup code, vector table, linker script and clock
  setup are all correct on this silicon.
- I2C master and the BME280 driver, remapped to PA15/PB7. The sensor answers
  with the right chip ID.

Verified earlier on the Nucleo, not yet ported over:

- The full BME280 read path — calibration read and reassembly plus Bosch's
  fixed-point compensation math. It streams real temperature, pressure and
  humidity, and the humidity climbs when you breathe on it.
- FDCAN at 500 kbit/s in internal loopback. A frame goes out, loops through
  the peripheral's message RAM, and comes back byte for byte.

In progress:

- BMI270 over SPI. The driver is written, including the 8 KB configuration
  blob the sensor needs uploaded before it will do anything, but the chip
  isn't answering yet — the chip ID read comes back wrong. The wiring checks
  out against the schematic, so it's something in the SPI setup or the read
  timing. Waiting on a 1.27mm SWD adapter so I can put a debugger on it
  instead of guessing.

Not working yet:

- CAN on a real bus. The MCU side checks out — I can read the FDCAN registers
  mid-transmit and see clean frames going out with no errors — but the
  transceiver breakout I was using never drives the bus. CANH and CANL sit at
  0.3 V when they should idle around 2.3 V, so the transceiver isn't operating
  at all. Either the part is dead or its slew rate resistor is limiting it
  well below 500 kbit/s.

## What's left

Port the remaining peripherals to the custom board, get the BMI270 talking,
write a UART driver so I can print values instead of stepping through a
debugger, pack sensor readings into CAN frames, and get those frames onto a
real bus where my laptop can decode them.

## KiCad design hardware/kicad/canarynode.kicad_pcb

Parts:
C1, C15: 10u; C_0603_1608Metric; LCSC C19702
C2: 22u; C_0603_1608Metric; LCSC C59461
C3, C5, C6, C21: 1u; C_0603_1608Metric; LCSC C15849
C4, C7, C8, C9, C10, C11, C13, C14, C16, C17, C18, C19, C20, C22: 100n; C_0402_1005Metric; LCSC C1525
C12: 4.7u; C_0603_1608Metric; LCSC C19666
D1: ESDZL5-1F4; D_0201_0603Metric; LCSC C2970171
D2: PESD2CANFD27V-TR; SOT23_PESD2_NEX; LCSC C552488
D3: LED; LED_0603_1608Metric; LCSC C2286
D4, D6: LED; LED_0603_1608Metric; LCSC C2287
D5: LED; LED_0603_1608Metric; LCSC C2289
J1, J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; LCSC C41417359
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J3: Screw_Terminal_01x03; PhoenixMC_1x03_P3.5_DB2EVC.kicad_mod; LCSC C430550
J5: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical_SMD; LCSC C4943297
J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical; LCSC C41417361
L1: 3.3u; IND_XFL3012_COC; LCSC C3911580
R1: 562k; R_0402_1005Metric; LCSC C48838
R2: 180k; R_0402_1005Metric; LCSC C25760
R3: 100k; R_0402_1005Metric; LCSC C25741
R4, R5, R6, R12, R13: 0R; R_0402_1005Metric; LCSC C17168
R7: 10k; R_0402_1005Metric; LCSC C25744
R8, R9: 5.1k; R_0402_1005Metric; LCSC C25905
R10, R11: 4.7k; R_0402_1005Metric; LCSC C25900
R14: 120R; R_0603_1608Metric; LCSC C22787
R15, R16, R17, R18: 330R; R_0402_1005Metric; LCSC C25104
SW1, SW2: SW_Push; SW_SPST_PTS645Sx43SMTR92; LCSC C6630024
U1: TPS62160DGK; MSOP-8_3x3mm_P0.65mm; LCSC C60726
U2: STM32G474RETx; LQFP-64_10x10mm_P0.5mm; LCSC C521608
U3: USBLC6-2P6; SOT-666; LCSC C15999
U4: BMI270; BMI270_BOS; LCSC C2836813
U5: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering; LCSC C92489
U6: TCAN334G; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C189939

Connections:
+3.3V: C2.1, C8.1, C9.1, C10.1, C11.1, C12.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, J1.1, J5.1, J6.2, L1.2, R1.1, R3.1, R4.1, R5.2, R10.1, R11.1, U1.6 (VOS), U2.16 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD), U4.5 (VDDIO), U4.8 (VDD), U5.2 (CSB), U5.6 (VDDIO), U5.8 (VDD), U6.3 (VCC)
+5V: C1.1, C14.1, C15.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U1.2 (VIN), U1.3 (EN), U3.5 (VBUS)
/BOOT0: J1.2, R7.1, U2.61 (PB8)
/BTN1: C22.1, SW2.2, U2.12 (PA0)
/CANH: D2.1, J3.1, R14.1, U6.7 (CANH)
/CANL: D2.2, J3.2, J4.2, U6.6 (CANL)
/FDCAN2_RX: U2.58 (PB5), U6.4 (RXD)
/FDCAN2_TX: U2.59 (PB6), U6.1 (TXD)
/I2C1_SCL: R10.2, U2.51 (PA15), U5.4 (SCK)
/I2C1_SDA: R11.2, U2.60 (PB7), U5.3 (SDI)
/IMU_INT1: U2.30 (PB10), U4.4 (INT1)
/LED1: R15.2, U2.24 (PB0)
/LED2: R16.2, U2.25 (PB1)
/LED3: R17.2, U2.26 (PB2)
/LED4: R18.2, U2.22 (PC4)
/NRST: C13.1, D1.2 (A2), J5.10, SW1.2, U2.7 (PG10)
/PG: R3.2, U1.8 (PG)
/SPI1_CS: U2.18 (PA4), U4.12 (CSB)
/SPI1_MISO: U2.20 (PA6), U4.1 (SDO)
/SPI1_MOSI: U2.21 (PA7), U4.14 (SDX)
/SPI1_SCK: U2.19 (PA5), U4.13 (SCX)
/SWCLK: J5.4, U2.50 (PA14)
/SWDIO: J5.2, U2.49 (PA13)
/SWO: J5.6, U2.56 (PB3)
/USART2_RX: J6.4, U2.17 (PA3)
/USART2_TX: J6.3, U2.14 (PA2)
/USB_DM: U2.45 (PA11), U3.4 (I/O2)
/USB_DM_RAW: J2.A7 (D-), J2.B7 (D-), U3.3 (I/O2)
/USB_DP: U2.46 (PA12), U3.6 (I/O1)
/USB_DP_RAW: J2.A6 (D+), J2.B6 (D+), U3.1 (I/O1)
/VDDA: C4.2, C5.2, R5.1, R6.1, U2.29 (VDDA)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D1.1 (A1), D2.3, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.3, J5.3, J5.5, J5.9, J6.1, R2.2, R7.2, R8.2, R9.1, R12.1, R13.1, SW1.1, SW2.1, U1.1 (PGND), U1.4 (AGND), U2.15 (VSS), U2.27 (VSSA), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS), U3.2 (GND), U4.6 (GNDIO), U4.7 (GND), U5.1 (GND), U5.5 (SDO), U5.7 (GND), U6.2 (GND)
unnamed: D3.2 (A), R15.1
unnamed: D4.2 (A), R16.1
unnamed: D5.2 (A), R17.1
unnamed: D6.2 (A), R18.1
unnamed: J2.A5 (CC1), R9.2
unnamed: J2.B5 (CC2), R8.1
unnamed: J4.1, R14.2
unnamed: R1.2, R2.1, U1.5 (FB)
unnamed: L1.1, U1.7 (SW)
unnamed: C3.2, R4.2, U2.1 (VBAT)
unnamed: C6.1, C7.1, R6.2, U2.28 (VREF+)
unnamed: R12.2, U6.5 (SHDN)
unnamed: R13.2, U6.8 (STB)

Notes on the sheet:
BOOT0 jumper (J1) = boot mode selector
POWER INPUT & 3.3V REGULATION USB-C VBUS (5V) → TPS62160 buck → 3.3V @ 1A
USER I/O & DEBUG: Status LEDs (D3-D6) on PC0-PC3, user button (SW2) on PC13, SWD header (J5) on PA13/PA14 + PB3 SWO, UART2 header (J6) on PA2/PA3
ENVIRONMENTAL SENSOR BME280 over I2C1 (addr 0x76) - temperature / pressure / humidity
USB-C DATA INTERFACE Type-C receptacle (J2) + USBLC6-2P6 ESD protection + 5.1kΩ CC pulldowns (UFP/sink mode) → STM32 USB FS (PA11/PA12)
end-of-bus enable
CAN FD TRANSCEIVER TCAN334GDR on FDCAN2 (PB5/PB6) + switchable 120Ω termination (J4) + PESD2CANFD27V TVS + 3-pin pluggable bus connector (J3)
SDO→GND = I2C addr 0x76 strap
MCU STM32G474RET6 - 170MHz Cortex-M4, 512KB Flash, FDCAN, USB FS + reset (SW1/NRST) + BOOT0 jumper (J1) + VDD/VDDA decoupling
6-AXIS IMU BMI270 over SPI1 (PA4 CS / PA5 SCK / PA6 MISO / PA7 MOSI) + INT1 on PB10

Board: 4 copper layers, 50.0 x 60.0 mm, 61 parts (0 on the bottom side), 45 nets.

File docs/canarynode-bom.csv:

Refdes Prefix,Value,Description,MFR Part Number,Manufacturer,LCSC P/N,JLCPCB Tier,Package,Quantity,Unit Price ($),Footprint,Notes
U1,TPS62160DGKR,"3V-17V to 3.3V buck converter, 1 A",TPS62160DGKR,Texas Instruments,C60726,Extended,VSON-8,9687,1.31,Package_SO:MSOP-8_3x3mm_P0.65mm,Powers entire 3.3V rail
L1,3.3uH,Power inductor,XFL3012-332MEC,Coilcraft,C3911580,Extended,3.0x3.0mm,126,1.01,Coilcraft_Local:IND_XFL3012_COC,
C1,10µF,"10V, X5R, 0603",CL10A106KP8NNNC,Samsung,C19702,Basic,0603,16300000,0.01,Capacitor_SMD:C_0603_1608Metric,Buck output
C2,22µF,"16V, X5R, 0603",CL10A226MQ8NRNC,Samsung,C59461,Basic,0603,14100000,0.01,Capacitor_SMD:C_0603_1608Metric,Buck input
R1,562kΩ,"0402, 1%",0402WGF5623TCE,Uni-Royal,C48838,Extended,0402,28178,,Resistor_SMD:R_0402_1005Metric,Buck FB divider
R2,180kΩ,"0402, 1%",0402WGF1803TCE,Uni-Royal,C25760,Extended,0402,720861,,Resistor_SMD:R_0402_1005Metric,Buck FB divider
R3,100kΩ,"0402, 1%",0402WGF1003TCE,Uni-Royal,C25741,Basic,0402,4092328,,Resistor_SMD:R_0402_1005Metric,Buck FB divider
U2,STM32G474RET6,"170 MHz Cortex-M4 MCU, 512 KB Flash, FDCAN, USB FS",STM32G474RET6,STMicroelectronics,C521608,Extended,LQFP-64,1,3.69,Package_QFP:LQFP-64_10x10mm_P0.5mm,Main MCU - pinout locked in CubeMX
SW1,SW_Push,Reset button,HX 3x4x2-2P-1.6N,hanxia,C49234124,Extended,SMD 3x4mm 2-pin,101172,0.01,Button_Switch_SMD:SW_SPST_TL3342,Cat 3 (convention pick)
D1,ESDZL5-1F4,USB ESD,ESDZL5-1F4,STMicroelectronics,C2970171,Extended,0201,3637,0.01,Diode_SMD:D_0201_0603Metric,Cat 2 (Nucleo reference exact match)
J1,Conn_01x02,2-pin 2.54mm header,HX PZ2.54-1x2P TP-YQ,hanxia,C41417359,Extended,1x2 2.54mm,4719,0.01,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,
"C3,C5,C6",1µF,"0603, X5R, 50V, ±10%",CL10A105KB8NNNC,Samsung,C15849,Basic,0603,,,Capacitor_SMD:C_0603_1608Metric,
C12,4.7µF,"0603, X5R, 16V, ±10%",CL10A475KO8NNNC,Samsung,C19666,Basic,0603,,,Capacitor_SMD:C_0603_1608Metric,
"C4,C7-C11,C13",100nF,"0402, X7R, 16V, ±10%",CL05B104KO5NNNC,Samsung,C1525,Basic,0402,,,Capacitor_SMD:C_0402_1005Metric,
R4-R6,0Ω,"0402, 1% (jumper)",0402WGF0000TCE,Uni-Royal,C17168,Basic,0402,,,Resistor_SMD:R_0402_1005Metric,
R7,10kΩ,"0402, 1%, 50V",0402WGF1002TCE,Uni-Royal,C25744,Basic,0402,,,Resistor_SMD:R_0402_1005Metric,
J2,USB_C_Receptacle_USB2.0_16P,"USB-C receptacle, USB 2.0, 16-pin SMD",TYPE-C-31-M-12,Korean Hroparts Elec,C165948,Basic,SMD,,,Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12,
U3,USBLC6-2P6,USB 2.0 ESD protection,USBLC6-2P6,STMicroelectronics,C15999,Extended,SOT-666,,,Package_TO_SOT_SMD:SOT-666,
"R8,R9",5.1kΩ,"0402, 1%",0402WGF5101TCE,Uni-Royal,C25905,Basic,0402,6333007,,Resistor_SMD:R_0402_1005Metric,USB-C CC pulldowns
C14,100nF,"0402, X7R, 16V, ±10%",CL05B104KO5NNNC,Samsung,C1525,Basic,0402,,,Capacitor_SMD:C_0402_1005Metric,
C15,10µF,"10V, X5R, 0603",CL10A106KP8NNNC,Samsung,C19702,Basic,0603,,,Capacitor_SMD:C_0603_1608Metric,
U4,BMI270,6-axis IMU,BMI270,Bosch,C2836813,Extended,LGA-14,,,BMI270:BMI270_BOS,
"C16,C17",100nF,"0402, X7R, 16V, ±10%",CL05B104KO5NNNC,Samsung,C1525,Basic,0402,,,Capacitor_SMD:C_0402_1005Metric,
U5,BME280,Environmental sensor (T/P/H),BME280,Bosch,C92489,Extended,LGA-8 2.5x2.5mm,,,Package_LGA:Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering,SDO tied to GND for I2C addr 0x76
"R10,R11",4.7kΩ,"0402, 1%",0402WGF4701TCE,Uni-Royal,C25900,Basic,0402,3286031,,Resistor_SMD:R_0402_1005Metric,I2C1 pullups
"C18,C19",100nF,"0402, X7R, 16V, ±10%",CL05B104KO5NNNC,Samsung,C1525,Basic,0402,,,Capacitor_SMD:C_0402_1005Metric,
U6,TCAN334GDR,"CAN FD transceiver, 3.3V logic, 5 Mbps",TCAN334GDR,Texas Instruments,C189939,Extended,SOIC-8,451,1.51,Package_SO:SOIC-8_3.9x4.9mm_P1.27mm,
"R12,R13",0Ω,"0402, 1% (jumper)",0402WGF0000TCE,Uni-Royal,C17168,Basic,0402,,,Resistor_SMD:R_0402_1005Metric,
C20,100nF,"0402, X7R, 16V, ±10%",CL05B104KO5NNNC,Samsung,C1525,Basic,0402,,,Capacitor_SMD:C_0402_1005Metric,
C21,1µF,"0603, X5R, 50V, ±10%",CL10A105KB8NNNC,Samsung,C15849,Basic,0603,,,Capacitor_SMD:C_0603_1608Metric,
D2,PESD2CANFD27V-TR,CAN bus ESD/TVS,PESD2CANFD27V-TR,Nexperia,C552488,Extended,SOT-23,,,PESD2CANFD27V-TR:SOT23_PESD2_NEX,
R14,120Ω,"0603, 1%, 100mW",0603WAF1200T5E,Uni-Royal,C22787,Basic,0603,1771326,,Resistor_SMD:R_0603_1608Metric,CAN termination
J3,Screw_Terminal_01x03,3-pin 3.5mm pluggable header (board side),DB2EVC-3.5-3P-GN,DORABO,C430550,Extended,3P 3.5mm,9225,,Connector_Phoenix_MC:PhoenixContact_MC_1,5_3-G-3.5_1x03_P3.50mm_Horizontal,Verify body outline silkscreen at PCB layout
J4,Conn_01x02,2-pin 2.54mm header,HX PZ2.54-1x2P TP-YQ,hanxia,C41417359,Extended,1x2 2.54mm,4719,0.01,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical,BOOT0 jumper
D3,LED red,"0603, Vf 1.8-2.4V",KT-0603R,Hubei Kento,C2286,Basic,0603,7918661,0.01,LED_SMD:LED_0603_1608Metric,
D4,LED amber,"0603, Vf 2.4V",KT-0603Y,Hubei Kento,C2287,Extended,0603,19755,0.01,LED_SMD:LED_0603_1608Metric,Originally spec'd green; swapped to amber for 330Ω compatibility
D5,LED yellow-green,"0603, Vf 2.0-2.2V",KT-0603YG,Hubei Kento,C2289,Extended,0603,48870,0.01,LED_SMD:LED_0603_1608Metric,
D6,LED amber,"0603, Vf 2.4V",KT-0603Y,Hubei Kento,C2287,Extended,0603,19755,0.01,LED_SMD:LED_0603_1608Metric,Duplicate of D4; distinguish by silkscreen + firmware blink pattern
R15-R18,330Ω,"0402, 1%",0402WGF3300TCE,Uni-Royal,C25104,Basic,0402,3378192,,Resistor_SMD:R_0402_1005Metric,LED current limiting
SW2,SW_Push,User button,HX 3x4x2-2P-1.6N,hanxia,C49234124,Extended,SMD 3x4mm 2-pin,101172,0.01,Button_Switch_SMD:SW_SPST_TL3342,Same part as SW1
C22,100nF,"0402, X7R, 16V, ±10%",CL05B104KO5NNNC,Samsung,C1525,Basic,0402,,,Capacitor_SMD:C_0402_1005Metric,
J5,Conn_02x05_Odd_Even,SWD header 10-pin 1.27mm 2x5 SMD,KH-1.27PH180-2X5P-L7.2-S,Shenzhen Kinghelm,C4943297,Extended,2x5 1.27mm SMD,2171,,Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical_SMD,ARM Cortex 10-pin Debug pinout
J6,Conn_01x04,UART header 4-pin 2.54mm,HX PZ2.54-1x4P TP-YQ,hanxia,C41417361,Extended,1x4 2.54mm,13668,0.01,Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical,

## Code that names these connections

File firmware/src/spi.c:

#include "spi.h"
#include <stdint.h>
#include "stm32g474xx.h"

/*
SCK: PA5: Mode AF5
MISO: PA6: Mode AF5
MOSI: PA7: Mode AF5
CS: PA4: Plan GPIO Output (Software controlled not hardware)
*/
void spi_init(void) {

// GPIOA Enable
RCC->AHB2ENR |= RCC_AHB2ENR_GPIOAEN; //port A pins (SCK/MISO/MOSI/CS)

// SPI Clock Enable
RCC->APB2ENR |= RCC_APB2ENR_SPI1EN; //spi peripheral (APB2)
// Pin Configuration (10=AF), (01=Output)
GPIOA->MODER &= ~(GPIO_MODER_MODE4 | GPIO_MODER_MODE5 | GPIO_MODER_MODE6 | GPIO_MODER_MODE7); // Clears MODER bits for PA 4,5,6,7
GPIOA->MODER |= (GPIO_MODER_MODE5_1 | GPIO_MODER_MODE6_1 | GPIO_MODER_MODE7_1 | GPIO_MODER_MODE4_0); // PA5,6,7 read 10 for AF, PA4 reads 01 since CS is a plain output I drive myself
// AFR[1] is pins 8-15, AFR[0] is pins 0-7
// Field for pin N = bits[Nx4 +3: Nx4]
// PA5: [23:20] | PA6: [27:24] | PA7: [31:28] | PA4 needs no AFR
GPIOA->AFR[0] &= ~((0xFu << 20) | (0xFu << 24) | (0xFu << 28)); //Clears the 4 bit fields for PA 5,6,7
GPIOA->AFR[0] |= ((5u << 20) | (5u << 24) | (5u << 28)); //store 5 for mode AF5 in each location

// OSPEEDR = Output Speed Register, 2 bits per pin (same shape as MODER), controls slew rate: how fast the driver swings the pin low<->high
// 11 = very high, default 00 is slow to keep EMI down but rounds off the edges. Only the outputs need it (SCK/MOSI), MISO is an input so its driver is unused
GPIOA->OSPEEDR |= (3u << (5*2)) | (3u << (7*2)); //PA5(SCK) and PA7(MOSI) to very high speed

/*
 CR1 Register Config:
 SPI Mode: CPOL (Clock polarity, what SCK sits at when idle, 0=low, 1=high)
           CPHA (Clock phase, which clock edge the data is captured on, 0=first edge 1=second edge)
 Per BMI270 DS: Supports 00 or 11 for CPOL/CPHA, I choose 00
 MSTR = 1 (Master driving)
 BR = 011 (/16) to take the MCU clock (16MHz) and scale it to 1MHz
 SSM (Software Slave Management), says software handles chip-select
 SSI (Internal Slave Select), pretends the line is HIGH (fake value we hand the MCU)
*/
SPI1->CR1 = (SPI_CR1_MSTR | SPI_CR1_BR_1 | SPI_CR1_BR_0 | SPI_CR1_SSM | SPI_CR1_SSI);

/*
 DS: Data Size, how big each chunk SPI sends. 
 ^ choose 8-bits for 1 byte messages, 8 bit is value 0111 in the DS field
 RXNE: Code waits for it then grabs the byte
 FIFO: 16 bit wide queue for incoming data
 Note: by default RXNE only raises when FIFO has 16-bits(2 bytes) in it.
 ^ FRXTH fixes the case that you only have 1 byte waiting, FRXTH =1 and RXNE fires as soon as 8 bits arrive instead of 16
*/
SPI1->CR2 = (SPI_CR2_DS_0 | SPI_CR2_DS_1 | SPI_CR2_DS_2 | SPI_CR2_FRXTH);

// Chip select is active-low, low=(selected, talk to me) - high=(deselected, ignore the bus)
// need CS to sit high (sensor deselected)
GPIOA->ODR |= GPIO_ODR_OD4; // drives PB7 high

// SPI Enable
SPI1->CR1 |= SPI_CR1_SPE; //turns on the spi for the peripheral
}

/*
    SPI hardware only knows how to 'swap' a byte: when the spi peripheral is handed one byte
    it clocks 8 bits out on MOSI and 8 bits in on MISO at the same time. 
    Drop byte into data register-> wait for hardware to say sent-> wait for it to say a byte came back-> read recevied byte
*/
uint8_t spi_transfer(uint8_t tx) { //tx is the byte sent, returns the received byte
    //TXE=Transmit Buffer Empty (send buffer is free)
    while(!(SPI1->SR & SPI_SR_TXE)); //spin until TXE is set
    
    // writing to Data Register (DR), must write tx
    // &SPI1->DR: address of DR
    // (volatile uint8_t *): treat addres as a pointer to a single byte (this forces the 16 bit read to 8)
    // *(...): write to the byte at that address 
    *(volatile uint8_t *)&SPI1->DR = tx; //8-bit write

    //RXNE: Receive buffer not empty (byte recieved)
    while(!(SPI1->SR & SPI_SR_RXNE)); // wait until a byte is ready to read

    // taking address of DR and relabeling its type to a pointer to a 8-bit value
    // derefencing the byte pointer, the compiler reads the 8-bits at that address
    uint8_t rx = *(volatile uint8_t *)&SPI1->DR;

    return rx;
}

/*
    BMI 270 specific: we need to send 3 transfers:
    1. MOSI(reg | 0x80), tells it to read this register, (MISO) sensor returns garbage
    2. MOSI(dummy(0x00)), just to make clock tick (full-duplex), (MISO) sensor returns the dummy byte
    3. MOSI(dummt(0x00)), makes the clock tick again, (MISO) sensor returns register value (KEEP)
*/
uint8_t spi_read_reg(uint8_t reg) { // read one register
    //Bit 7 of the address byte = R/W flag. bit7=1: read, bit7=0: write
    //ex: read register 0x00, set bit 7 to 1 -> 0x00 | 0x80 = 0x80, or with the 7 bit set (0x80)

    // Step 1: Drive CS(PA4) low
    GPIOA->ODR &= ~(GPIO_ODR_OD4);

    // Step 2: send address, ignore return, OR with bit7=1 for read
    spi_transfer(reg | 0x80); 

    // Step 3: dummy transfer, bmi270 specific
    spi_transfer(0x00);

    // Step 4: send another dummy, keep result
    uint8_t value = spi_transfer(0x00);

    // Step 5: set CS // drives PA4 high
    GPIOA->ODR |= GPIO_ODR_OD4;

    return value;
}

void spi_write_reg(uint8_t reg, uint8_t val) {
    //Step 1: Pull CS low
    GPIOA->ODR &= ~(GPIO_ODR_OD4);
    
    // Step 2: send address to write at
    spi_transfer(reg);

    // Step 3: send value to write
    spi_transfer(val);

    //Step 4: Pull CS high
    GPIOA->ODR |= GPIO_ODR_OD4;
}

void spi_read_burst(uint8_t reg, uint8_t *buf, uint16_t n) {
    //Step 1: Pull CS low
    GPIOA->ODR &= ~(GPIO_ODR_OD4);

    // Step 2: send address, ignore return, OR with bit7=1 for read
    spi_transfer(reg | 0x80); 

    // Step 3: dummy transfer, bmi270 specific (Only have to discard one time)
    spi_transfer(0x00);

    // Step 4: read each transfer into the buffer
    for (int i = 0; i < n; i++) {
        buf[i] = spi_transfer(0x00); //sesnor auto incrememnts wihtin the register from the initial transfer
    }

    //Step 5: CS high
    GPIOA->ODR |= GPIO_ODR_OD4;
}

void spi_write_burst(uint8_t reg, const uint8_t *buf, uint16_t n) {
    //Step 1: Pull CS low
    GPIOA->ODR &= ~(GPIO_ODR_OD4);
    
    // Step 2: send address to write at, bit7=0 so sensor knows write
    spi_transfer(reg);

    //Step 3: Write to the register multiple increments
    for (int i = 0; i < n; i++) {
        spi_transfer(buf[i]); //writes each consecutive item in the buffer
    }

    //Step 4: CS high
    GPIOA->ODR |= GPIO_ODR_OD4;
}

## Commit log (part)

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2026-05-21 Initial commit: week 1 deliverables (block diagram, power tree, pin map, BOM scaffold, KiCad project)
2026-05-21 Ignore KiCad lock files
2026-05-21 Add Nucleo-G474RE reference schematic; library and tooling setup complete
2026-05-21 Pre-KiCad audit: CAN FD swap, IMU INT1 wiring, TCAN334G mode pins, VBAT/VREF TODOs
2026-05-21 schematic: TPS62160 buck subcircuit complete (5V to 3.3V/1A)
    TPS62160DGKR adjustable buck, VSSOP-8 (C60726)
    - L=3.3uH XFL3012-332MEC for low-VIN operation per datasheet 9.2.2.4
    - C1=10uF/10V X5R 0603 (C19702), C2=22uF/6.3V X5R 0603 (C59461)
    - FB divider: R1=562k, R2=180k for Vout=3.30V per Eq 6 (Vref=0.8V)
    - R3=100k PG pull-up to +3.3V; PG net labeled for future GPIO/test point
    - VOS routed to VOUT at output cap per 11.1 layout guidance
2026-05-24 schematic: STM32G474 MCU subcircuit complete
    - U2 STM32G474RET6 in LQFP-64 (C521608)
    - Decoupling per datasheet Fig 16 + Nucleo MB1367
    - 4x 100nF + 4.7uF bulk on VDD pins 16/32/48/64
    - 100nF + 1uF on VDDA (Nucleo divergence: datasheet says 10nF)
    - 100nF + 1uF on VREF+
    - 1uF on VBAT
2026-05-24 schematic: add USB-C subcircuit (J2, U3, R8/R9, C14/C15)
2026-05-24 Add BME280 environmental sensor (U5, I2C1, addr 0x76)
2026-05-24 Add CAN FD bus: TCAN334G transceiver, 120Ω switchable termination, PESD2CANFD27V TVS, 3.5mm screw terminal
2026-05-25 Add LEDs, button, SWD header, UART header
2026-05-25 v1.0-schematic-complete: pre-layout validation done
    - All 9 validation categories cleared
    - Footprint fixes: J3 drill 1.4mm, SW1/SW2 swap to C6630024
    - I2C1 pin assignment corrected to PA15/PB7
    - Board outline 50x60mm, SIG/GND/GND/SIG stackup
    - BOM finalized, 61 components
2026-05-25 docs(sch): add annotation labels for J1 BOOT0, J4 CAN term, BME280 addr strap
2026-05-26 pcb: configure board setup - layers (SIG/GND/GND/SIG), net classes, DRC constraints
2026-05-26 pcb: place edge connectors, MCU, ICs, buck/CAN/MCU decoupling clusters
2026-05-28 pcb: complete component placement — all 61 placed, DRC clean (unrouted)
2026-05-30 pcb: stitch GND island vias, silkscreen cleanup, DRC clean
2026-05-30 fab: generate gerbers + drill files for JLC
2026-05-30 fab: add LCSC to BOM, generate CPL, exclude mounting holes from placement, remove stale datasheet
2026-05-30 chore: gitignore plugin output, DS_Store, lock files
2026-06-12 Add firmware tree; update PCB layout and BOM
2026-06-18 initial blink LED
2026-06-18 Stop tracking RM0440 PDF; gitignore vendor docs
2026-06-25 CAN Progress
